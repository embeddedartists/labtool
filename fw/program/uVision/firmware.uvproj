# Keil uVision project firmware.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: LPC4320 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: firmware
  AfterMake: fromelf --bin -o "$P\..\..\@L.bin" "$L@L.axf"
  AfterMake: findstr /C:"(Base:" "$L@L.map"
  c flags: Optim=4 wLevel=2
  c define: CORE_M4 USE_SPIFI_LIB __LPC43XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\Lib_CMSIS\Include;..\..\Lib_Drivers\include;..\..\Lib_MCU\include;..\..\Lib_USB;..\..\Lib_USB\LPCUSBLib\Drivers\USB;..\include;..\sct
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x13000
  memory RVCT8: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10013000 size 0x5000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Lib_Drivers
    ../../Lib_Drivers/source/: lpc43xx_cgu_improved.c spi_control.c spi_dac.c spi_eeprom.c
  group Lib_MCU
    ../../Lib_MCU/source/: debug_frmwrk.c lpc43xx_adc.c lpc43xx_atimer.c lpc43xx_cgu.c lpc43xx_dac.c lpc43xx_gpdma.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_nvic.c lpc43xx_rgu.c lpc43xx_sct.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_uart.c lpc43xx_wwdt.c system_LPC43xx.c
  group Lib_USB
    ../../Lib_USB/LPCUSBLib/Drivers/USB/Core/: DeviceStandardReq.c Events.c USBMemory.c USBTask.c
    ../../Lib_USB/LPCUSBLib/Drivers/USB/Core/LPC/: Device_LPC.c Endpoint_LPC.c EndpointStream_LPC.c Pipe_LPC.c PipeStream_LPC.c USBController_LPC.c
    ../../Lib_USB/LPCUSBLib/Drivers/USB/Core/LPC/HAL/LPC18XX/: HAL_LPC18xx.c
    ../../Lib_USB/LPCUSBLib/Drivers/USB/Core/LPC/DCD/LPC18XX/: Endpoint_LPC18xx.c
    ../../Lib_USB/: bsp.c
  group SCT
    ../sct/: freq_measure.fzm freq_measure.inc sct_fsm.c sct_fsm.h sct_user.h
  group Header Files
    ../include/: error_codes.h led.h labtool_config.h meas.h
  group Source Code
    ../source/: calibrate.c capture.c capture_sgpio.c capture_vadc.c circbuff.c experiments.c generator.c generator_dac.c generator_sgpio.c log.c main.c monitor_i2c.c sgpio_cfg.c startup_LPC43xx.s statemachine.c usb_descriptors.c usb_handler.c
  group Documentation
    ../../: readme.txt
